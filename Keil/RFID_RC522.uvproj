# Keil uVision project RFID_RC522.uvproj, settings and files
target RFID_RC522 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: RFID_RC522 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Main
    ./Src/: main.c main.h
  group UART
    ./Src/: UART.c UART.h
  group RC522
    ./Src/: RC522.c RC522.h
  group TIMER
    ./Src/: TIMER.c TIMER.h
  group Mini12864
    ./Src/: Mini12864.c Mini12864.h Mini12864Font.h
  group Motor
    ./Src/: Motor.c Motor.h
  group DS1302
    ./Src/: DS1302.c DS1302.h
  group Infrared
    ./Src/: Infrared.c Infrared.h
